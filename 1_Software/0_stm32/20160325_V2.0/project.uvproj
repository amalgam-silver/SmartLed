# Keil uVision project project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,OLED_SPI_3WIRE
  c include: .\Library\STM32F10x_StdPeriph_Driver\inc;.\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Code\App;.\Code\Board;.\Code\Cpu
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ./Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Documents
    ./: readme.txt
  group App
    ./Code/App/: picture.c main.c Manage.c GUI.c Task.c Widget.c Protocol.c Power.c
  group Board
    ./Code/Board/: BspOledFont.c Bsp.c BspRtc.c BspTemp.c BspBle.c BspBattery.c BspKey.c BspOled.c BspLed.c BspTimer.c
  group Cpu
    ./Code/Cpu/: stm32_systick.c stm32_pwm.c stm32_i2c.c stm32_adc.c stm32_uart.c stm32_rcc.c stm32_spi.c
